# Keil uVision project STM32F407VET6.uvprojx, settings and files
target STM32F407VET6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F407VET6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,EncodingWheel,__FPU_PRESENT=1, __TARGET_FPU_VFP, ARM_MATH_CM4, __CC_ARM,HSE_VALUE=16000000
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\User\BSP\inc;..\User\Function\inc;..\User\Task\inc;../RT-Thread;../Middlewares/Third_Party/RealThread_RTOS/include/;../Middlewares/Third_Party/RealThread_RTOS/bsp/_template/cubemx_config;../Middlewares/Third_Party/RealThread_RTOS/finsh/;../Middlewares/Third_Party/RealThread_RTOS/components/finsh;..\User\CAN_Communication;..\User\CAN_Communication\SlaveControlPanel;..\User\AdUI\inc;..\User\SCSLib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ../User/Function/src/: RecognitionModule.c
    ./: startup_stm32f407xx.s
    ../: arm_cortexM4lf_math.lib
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/RT-Thread/RTOS/kernel
    ../Middlewares/Third_Party/RealThread_RTOS/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
    ../Middlewares/Third_Party/RealThread_RTOS/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group Middlewares/RT-Thread/RTOS/shell
    ../Middlewares/Third_Party/RealThread_RTOS/components/finsh/: cmd.c finsh_port.c msh.c shell.c
  group BSP
    ../User/Function/src/: CheckCalc.c
    ../User/BSP/inc/: rtconfig.h
    ../User/BSP/src/: board.c bsp.c bsp_hal_gpio.c bsp_hal_time_CMPx_BEEP.c bsp_hal_uartdma.c bsp_hal_st7735s.c bsp_lcd_font.c bsp_hal_can.c
  group FUNCTION
    ../User/Function/src/: separate_button.c chassis_function.c bus_servo.c Location_Tracker.c pid.c
  group CAN_Communication
    ../User/CAN_Communication/: CAN_Communication.c CAN_Communication_canconfig.c
    ../User/CAN_Communication/SlaveControlPanel/SLAVE_DCMotorMiniwatt/: SLAVE_DCMotorMiniwatt.c
    ../User/CAN_Communication/SlaveControlPanel/SLAVE_SteeringEngine_6CH/: SLAVE_SteeringEngine_6CH.c
    ../User/CAN_Communication/SlaveControlPanel/SLAVE_Tracking/: SLAVE_Tracking.c
  group TASK
    ../User/Task/src/: data.c thread_led.c thread_gui.c thread_comm.c thread_rccu.c thread_user.c
    ../User/SCSLib/: Servo.c
    ./: TestCode.c
  group UI
    ../User/AdUI/src/: mmenu.c
  group SCSLib
    ../User/SCSLib/: SCS.c SCSerail.c SMS_STS.c
software components: CMSIS:CORE 4.3.0
